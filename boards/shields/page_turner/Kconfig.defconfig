## boards/shields/page_turner/Kconfig.defconfig
```kconfig
if SHIELD_PAGE_TURNER

config ZMK_KEYBOARD_NAME
    default "PageTurner9000"

endif
```
